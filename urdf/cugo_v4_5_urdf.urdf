Commit message: URDFを最新のモデルに更新

File: urdf/cugo_v4_5_urdf.urdf (robot description, URDF)
Before this commit: robot cugo_v4_5_urdf, 1 links, 0 joints
Links:
- link base_footprint: mass 29.0 -> 27.0
